Spice circuit Gen

R1 0 w3 5
R2D2 0 w2 4
Kappa w1 w2 0.5
V w1 w3 10
