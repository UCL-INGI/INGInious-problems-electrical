Spice circuit Gen

R1 w23 w25 5
R2D2 w23 w34 4
Kappa w45 w34 0.5
V w45 w25 10
